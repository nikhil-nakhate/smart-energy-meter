# IAR project SampleApp.ewp, settings and files
configuration ESP - Coordinator (MSP430, debug)
  General.OGChipSelectMenu: MSP430F5438A MSP430F5438A
  General.GStackSize2: 512
  General.GHeapSize2: 0
  General.RadioHeapSizeType: 0
  ICC430.CCDefines: ZAP_DEVICETYPE=ZG_DEVICETYPE_COORDINATOR; TC_LINKKEY_JOIN; ZCL_REPORT; INTER_PAN
  ICC430.CCDiagSuppress: Pe001,Pe193,Pe236,Pe826
  ICC430.IExtraOptions: -f ..\..\Source\zap.cfg; -f ..\..\..\Tools\MSP5438\f8wZCL.cfg
  ICC430.newCCIncludePaths: $PROJ_DIR$; ..\Source; ..\..\Source; ..\..\..\..\..\Components\hal\target\MSP5438ZAP; ..\..\..\..\..\Components\hal\include; ..\..\..\..\..\Components\mac\include; ..\..\..\..\..\Components\mt; ..\..\..\..\..\Components\osal\include; ..\..\..\..\..\Components\osal\mcu\msp430; ..\..\..\..\..\Components\services\saddr; ..\..\..\..\..\Components\services\sdata; ..\..\..\..\..\Components\stack\af; ..\..\..\..\..\Components\stack\nwk; ..\..\..\..\..\Components\stack\sapi; ..\..\..\..\..\Components\stack\sec; ..\..\..\..\..\Components\stack\sys; ..\..\..\..\..\Components\stack\zcl; ..\..\..\..\..\Components\stack\zdo; ..\..\..\..\..\Components\zmac; ..\..\..\..\..\Components\zmac\f8w
  ICC430.CCOptLevel: 3
  ICC430.CCOptStrategy: 1
  ICC430.IccLang: 0
  XLINK.XclFile: ..\..\..\Tools\MSP5438\MSP430F5438.xcl
  XLINK.XlinkStackSize: 1
configuration Simple Metering - Router (MSP430, debug)
  as the first configuration, except:
  ICC430.CCDefines: ZAP_DEVICETYPE=ZG_DEVICETYPE_ROUTER; TC_LINKKEY_JOIN; ZCL_REPORT
configuration Simple Metering - End Device (MSP430, debug)
  as the first configuration, except:
  General.OGChipSelectMenu: MSP430F5438 MSP430F5438
  ICC430.CCDefines: ZAP_DEVICETYPE=ZG_DEVICETYPE_ENDDEVICE; TC_LINKKEY_JOIN; ZCL_REPORT
configuration Load Control Device - Router (MSP430, debug)
  as the first configuration, except:
  General.OGChipSelectMenu: MSP430F5438 MSP430F5438
  ICC430.CCDefines: ZAP_DEVICETYPE=ZG_DEVICETYPE_ROUTER; TC_LINKKEY_JOIN
configuration In Premise Display - End Device (MSP430, debug)
  as the first configuration, except:
  General.OGChipSelectMenu: MSP430F5438 MSP430F5438
  ICC430.CCDefines: ZAP_DEVICETYPE=ZG_DEVICETYPE_ENDDEVICE; TC_LINKKEY_JOIN; INTER_PAN
configuration PCT - End Device (MSP430, debug)
  as the first configuration, except:
  General.OGChipSelectMenu: MSP430F5438 MSP430F5438
  ICC430.CCDefines: ZAP_DEVICETYPE=ZG_DEVICETYPE_ENDDEVICE; TC_LINKKEY_JOIN
configuration Range Extender - Router (MSP430, debug)
  as the first configuration, except:
  General.OGChipSelectMenu: MSP430F5438 MSP430F5438
  ICC430.CCDefines: ZAP_DEVICETYPE=ZG_DEVICETYPE_ENDDEVICE; TC_LINKKEY_JOIN
  group (top)
    ../Source/ESP/: esp.h
  group Application/ESP
    ../Source/ESP/: esp.c esp_data.c OSAL_esp.c
  group Application/In Premise Display
    ../Source/IPD/: ipd.c ipd.h ipd_data.c OSAL_ipd.c
  group Application/Load Control Device
    ../Source/LoadControl/: loadcontrol.c loadcontrol.h loadcontrol_data.c OSAL_LoadControl.c
  group Application/PCT
    ../Source/PCT/: OSAL_pct.c pct.c pct.h pct_data.c
  group Application/RangeExt
    ../Source/RangeExt/: OSAL_RangeExt.c rangeext.c rangeext.h rangeext_data.c
  group Application/Simple Metering
    ../Source/SimpleMeter/: OSAL_SimpleMeter.c simplemeter.c simplemeter.h simplemeter_data.c
  group HAL/Common
    ../../../../../Components/hal/common/: hal_assert.c hal_drivers.c
    ../../../../../Components/hal/include/: hal_assert.h hal_defs.h hal_drivers.h
  group HAL/Drivers
    ../../../../../Components/hal/include/: hal_adc.h hal_key.h hal_lcd.h hal_led.h hal_timer.h hal_uart.h
  group HAL/Target/Config
    ../../../../../Components/hal/target/MSP5438ZAP/: hal_board.h hal_board_cfg.h hal_dco.c hal_dco.h hal_startup.c
  group HAL/Target/Drivers
    ../../../../../Components/hal/target/MSP5438ZAP/: hal_adc.c hal_board.c hal_key.c hal_lcd.c hal_led.c hal_main.c hal_spi.c hal_timer.c hal_uart.c
  group HAL/Target/Includes
    ../../../../../Components/hal/target/MSP5438ZAP/: hal_mcu.h hal_spi.h hal_types.h
  group MT
    ../../../../../Components/mt/: MT.h MT_AF.h MT_MAC.h MT_RPC.h MT_SYS.h MT_UART.h MT_UTIL.h mt_version.h MT_ZDO.h
  group OSAL
    ../../../../../Components/osal/mcu/msp430/: MSP430FlashUtil.c MSP430FlashUtil.h OSAL_Nv.c
    ../../../../../Components/osal/common/: OSAL.c OSAL_Memory.c OSAL_PwrMgr.c OSAL_Timers.c
    ../../../../../Components/osal/include/: OSAL.h OSAL_Memory.h OSAL_Nv.h OSAL_PwrMgr.h OSAL_Tasks.h OSAL_Timers.h ZComDef.h
  group Profile
    ../../Source/: se.c se.h
    ../../../../../Components/stack/zcl/: zcl.c zcl.h zcl_general.c zcl_general.h zcl_se.c zcl_se.h
  group Services
    ../../../../../Components/services/saddr/: saddr.c saddr.h
    ../../../../../Components/stack/sapi/: sapi.h
  group Tools
    ../../../Tools/MSP5438/: f8wZCL.cfg MSP430F5438.xcl
    ../../Source/: zap.cfg
  group ZAP
    ../../Source/: zap_af.c zap_app.c zap_app.h zap_certs.c zap_phy.c zap_phy.h zap_sapi.c zap_stub_aps.c zap_sys.c zap_util.c zap_zdo.c zap_zmac.c zap_znp.c zap_znp.h
